# Keil uVision project HardwareDesign-v2.1.uvprojx, settings and files
target HardwareDesign (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HardwareDesign-v2.1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Core;..\FWlib\inc;..\FWlib\src;..\Algorithm;..\Driver;..\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Core
    ../Core/: startup_stm32f40_41xxx.s
  group User
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group FWlib
    ../FWlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Driver
    ../Driver/: Adc.c Delay.c Driver_Init.c Encode.c GPIO.c GPIO_Init.c IIC.c IWDG.c LED_Key.c Oled.c Probe_Cap.c STMFlash.c USART.c
  group Algorithm
    ../Algorithm/: SystemTim.c Driver_Control.c CurveFitted.c Probe_Calibrate.c CommonFunc.c
